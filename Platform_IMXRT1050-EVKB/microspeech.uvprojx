# Keil uVision project microspeech.uvprojx, settings and files
target IMXRT1050-EVKB (6210000::V6.21::ARMCLANG)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.17.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: microspeech
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: __EVENT_DRIVEN CODEC_WM8960_ENABLE, SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  c include: .;..\VSI\audio\include;..\micro_speech\src
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1052DVL6B\MIMXRT1052xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group App
    ./: microspeech.c
  group Board
    ./: main.c main.h
  group Board IO
    ./Board_IO/: retarget_stdio.c
  group Driver
    ./Driver_Audio/: Audio_IMXRT1050-EVKB.c
  group MCUXpresso
    ./: IMXRT1050-EVKB.mex
  group Documentation
    ./: README.md
  group TF_micro_frontend
    ../micro_speech/src/microfrontend/lib/: fft.cc fft_util.cc filterbank.c filterbank_util.c frontend.c frontend_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c window.c window_util.c
  group TF_micro_features
    ../micro_speech/src/micro_features/: micro_features_generator.cc micro_model_settings.cc model.cc no_micro_features_data.cc yes_micro_features_data.cc
  group TF_main
    ../micro_speech/src/: audio_provider.cc command_responder.cc feature_provider.cc main.cc main_functions.cc recognize_commands.cc arm_nn_softmax_common_s8.c
  group nn_add
    ../nn_add/: arm_s8_to_s16_unordered_with_offset.c
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:DSP 1.15.0, CMSIS:NN Lib 4.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.3.0, CMSIS Driver:MCI 1.5.0, CMSIS Driver:VIO:Board 2.0.0, Board Support:SDK Drivers:evkbimxrt1050 xip 2.0.1, Board Support:SDK Project Template:project_template 1.0.0, CMSIS Driver:USART:lpuart_cmsis 2.4.0, Device:CMSIS:MIMXRT1052_header 1.0.0, Device:CMSIS:MIMXRT1052_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:codec 2.3.1, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.4.0, Device:SDK Drivers:dmamux 2.1.0, Device:SDK Drivers:edma 2.4.3, Device:SDK Drivers:enet 2.7.0, Device:SDK Drivers:fxos8700cq 1.0.0, Device:SDK Drivers:gpio 2.0.6, Device:SDK Drivers:i2c 2.5.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.7.3, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.6.0, Device:SDK Drivers:nic301 2.0.1, Device:SDK Drivers:sai 2.3.8, Device:SDK Drivers:sai_edma 2.5.1, Device:SDK Drivers:sdhc 2.8.2, Device:SDK Drivers:wm8960 2.2.2, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_device 2.0.3, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.1, Device:SDK Utilities:serial_manager 1.0.1, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup 1.1.0, Data Exchange:Serialization:flatbuffers 1.22.5-rc4, Data Processing:Math:gemmlowp fixed-point 1.22.5-rc4, Data Processing:Math:kissfft 1.22.5-rc4, Data Processing:Math:ruy 1.22.5-rc4, Machine Learning:TensorFlow:Kernel Utils 1.22.5-rc4, Machine Learning:TensorFlow:Kernel 1.22.5-rc4
